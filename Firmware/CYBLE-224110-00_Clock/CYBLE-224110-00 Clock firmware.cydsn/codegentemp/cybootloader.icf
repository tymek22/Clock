/* GENERATED CODE -- CHANGES WILL BE OVERWRITTEN */

define symbol CYDEV_BTLDR_SIZE = 0x0001FD00;
